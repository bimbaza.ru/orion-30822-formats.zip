Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:20+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Батут уличный, ZSK-TRM-UFO Батут «Летающая тарелка»
In: Площадка
Description: Батут уличный. Батут «Летающая тарелка»
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-TRM-UFO; ModelReference: Батут «Летающая тарелка»; ProductionYear: 2026; ArticleNumber: ZSK-TRM-UFO
ORION_Изделие - Артикул: ZSK-TRM-UFO; Артикул прежний: SD-TRM-UFO; Наименование: Батут «Летающая тарелка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3400 × 3400 мм; Цена: 1 000 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/trampolines/30822; Код КСИ: CPr>EDFC; Класс КСИ: Арт-объекты; Коды КСР: …
ADSK - ADSK_Наименование: Батут «Летающая тарелка»; ADSK_Марка: ZSK-TRM-UFO; ADSK_Код изделия: ZSK-TRM-UFO; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/trampolines/30822
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDFC; ZSK_Артикул_прежний: SD-TRM-UFO
Qto_ORION - Длина: 3400 mm; Ширина: 3400 mm; Высота: 0 mm
